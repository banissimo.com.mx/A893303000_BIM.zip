Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Toilets_Roca_MERIDIAN-IN-TANK-WC-back-to-wall.ifc.ifc
Time: 2021-11-03T17:01:25
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - IfcClassification (BO_ifcclas): Sanitary Terminal
